# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429 +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c include: ..\src\app;..\src\cmsis\inc;..\src\raw-os\kernel\include;..\src\raw-os\port;..\src\stm32f429;..\src\stm32f429\driver\inc;..\src\raw-os\kernel\extension\include;..\src\bsp;..\src\lua;..\src\fatfs;..\src\lib
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\src\config\stm32f429.sct
  group app
    ../src/app/: main.c sys_init.c debug_uart.c sys_led.c lua_task.c fatfs_init.c
  group lib
    ../src/lib/: lua_fatfs.c serial_fifo.c ymodem.c lua_exlibs.c
  group stm32f429
    ../src/stm32f429/: startup_stm32f429_439xx.s stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c stm32f4xx_it.c
  group std_driver
    ../src/stm32f429/driver/src/: stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fmc.c stm32f4xx_dma.c stm32f4xx_ltdc.c stm32f4xx_spi.c stm32f4xx_dma2d.c misc.c
  group config
    ../src/raw-os/kernel/include/: raw_config.h
    ../src/stm32f429/: stm32f4xx_conf.h
    ../src/config/: stm32f429.sct
    ../src/lua/: luaconf.h
    ../src/fatfs/: ffconf.h
    ../src/cli/: cli_config.h
  group raw-os
    ../src/raw-os/kernel/: raw_block.c raw_byte.c raw_event.c raw_idle.c raw_idle_event.c raw_mqueue.c raw_mutex.c raw_obj.c raw_pend.c raw_queue.c raw_queue_buffer.c raw_queue_size.c raw_sched.c raw_sem.c raw_stat.c raw_stm.c raw_system.c raw_task.c raw_task_0.c raw_task_queue_size.c raw_task_sem.c raw_tick.c raw_timer.c
  group port
    ../src/raw-os/port/: cpu.asm port.c port.h port_hook.c port_idle_config.h raw_cpu.h raw_trace_port.c raw_type.h
  group raw-os-extension
    ../src/raw-os/kernel/extension/lib/: simple_printf.c
    ../src/raw-os/: user_extension.c
    ../src/raw-os/kernel/extension/mm/: raw_tlsf.c
  group bsp
    ../src/bsp/: bsp.c stm32f429i_discovery_sdram.c retarget.c stm32f429i_discovery_lcd.c bsp.h
  group lua
    ../src/lua/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lvm.c lzio.c
  group fatfs
    ../src/fatfs/: diskio.c ff.c
    ../src/fatfs/option/: unicode.c
  group cli
    ../src/cli/: cmds.c cli.c cli_port.c cli_readline.c cli_simple.c command.c
